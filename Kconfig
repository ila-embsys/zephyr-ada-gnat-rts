## Kconfig
```kconfig
menuconfig ADA_GNAT_RTS
    bool "ADA_GNAT_RTS"
    help
        GNAT Ada Run Time Systems
```
